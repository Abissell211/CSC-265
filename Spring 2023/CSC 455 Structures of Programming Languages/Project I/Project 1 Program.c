#include <stdio.h>
#include <stdlib.h>
#include <time.h>

#define ARRAYSIZE 100

int main(){

//--------------------------------------------------------------------------------------------//
//---------------------------------------Variable Init----------------------------------------//
//--------------------------------------------------------------------------------------------//	
	clock_t start_t, end_t;
	double total_t1, total_t2;
	
	int i,j,test;								
	
	int A[ARRAYSIZE][ARRAYSIZE];
	int *p1 = &A[0][0];
	
//--------------------------------------------------------------------------------------------//
//----------------------------------------Subscripting----------------------------------------//
//--------------------------------------------------------------------------------------------//
	printf("\nStart for subscripting references\n");
	start_t = clock();
	
	for(i = 0; i < ARRAYSIZE; i++){
		for(j = 0; j < ARRAYSIZE; j++){
			test = A[i][j];
			printf("A[%d][%d] : %d\n", i, j, test);
		}
	}
	
	end_t = clock();
	total_t1 = (double)(end_t - start_t) / CLOCKS_PER_SEC;
	printf("\n//--------------------------------------------------------------------------------------------//");
	printf("\n//--------------------------------------------------------------------------------------------//");
	printf("\n//--------------------------------------------------------------------------------------------//\n");

//--------------------------------------------------------------------------------------------//
//------------------------------------------Pointer-------------------------------------------//
//--------------------------------------------------------------------------------------------//	
	printf("\nStart for pointer references\n");
	start_t = clock();
	
	for(i = 0; i < ARRAYSIZE*ARRAYSIZE; i++){
		test = *(p1 + i);
		printf("*(p + %d) : %d\n", i, *(p1+i));
		}

	
	end_t = clock();
	total_t2 = (double)(end_t - start_t) / CLOCKS_PER_SEC;
	
//--------------------------------------------------------------------------------------------//
//----------------------------------------Clock Times-----------------------------------------//
//--------------------------------------------------------------------------------------------//
	printf("Time taken for subscripting references: %f\n", total_t1);	
	printf("Time taken for pointer references: %f\n", total_t2);
	
	return(0);
}
